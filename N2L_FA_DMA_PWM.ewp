# IAR project N2L_FA_DMA_PWM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G084M04 Renesas R9A07G084M04
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 49
  General.FPU2: 8
  ICCARM.CCDefines: _RENESAS_RZN_; _RZN_CORE=CR52_0
  ICCARM.CCIncludePath2: rzn/arm/CMSIS_5/CMSIS/Core_R/Include; rzn/fsp/inc; rzn/fsp/inc/api; rzn/fsp/inc/instances; rzn_cfg/fsp_cfg; rzn_cfg/fsp_cfg/bsp; rzn_gen; src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _RENESAS_RZN_; _RZN_CORE=CR52_0
  AARM.AUserIncludes: as above
  postbuild: cmd /c ""$RASC_EXE_PATH$" -nosplash --launcher.suppressErrors --gensmartbundle --compiler IAR --devicefamily rzn "configuration.xml" "$TARGET_PATH$" 2> "%TEMP%\rasc_stderr.out""
  ILINK.IlinkOutputFile: N2L_FA_DMA_PWM.out
  ILINK.IlinkIcfFile: script/fsp_ram_execution.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RENESAS_RZN_; _RZN_CORE=CR52_0
  ICCARM.CCOptLevel: 3
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    rzn_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_pin_cfg.h
    rzn_cfg/fsp_cfg/: r_dmac_cfg.h r_gpt_cfg.h r_ioport_cfg.h r_mtu3_cfg.h r_mtu3_three_phase_cfg.h r_poe3_cfg.h r_sci_uart_cfg.h
  group Flex Software/Components
    rzn/board/rzn2l_rsk/: board.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
    rzn/fsp/inc/api/: bsp_api.h r_ioport_api.h r_poe3_api.h r_three_phase_api.h r_timer_api.h r_transfer_api.h r_uart_api.h
    rzn/fsp/src/bsp/mcu/rzn2l/: bsp_cache.c bsp_cache.h bsp_elc.h bsp_feature.h bsp_loader_param.c bsp_mcu_info.h
    rzn/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_reset.c bsp_reset.h bsp_sbrk.c bsp_tfu.h
    rzn/arm/CMSIS_5/CMSIS/Core_R/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cr52.h
    rzn/fsp/inc/: fsp_common_api.h fsp_features.h fsp_version.h
    rzn/arm/CMSIS_5/: LICENSE.txt
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R9A07G084.h renesas.h system.h
    rzn/fsp/src/r_dmac/: r_dmac.c
    rzn/fsp/inc/instances/: r_dmac.h r_gpt.h r_ioport.h r_mtu3.h r_mtu3_three_phase.h r_poe3.h r_sci_uart.h
    rzn/fsp/src/r_gpt/: r_gpt.c
    rzn/fsp/src/r_ioport/: r_ioport.c
    rzn/fsp/src/r_mtu3/: r_mtu3.c
    rzn/fsp/src/r_mtu3_three_phase/: r_mtu3_three_phase.c
    rzn/fsp/src/r_poe3/: r_poe3.c
    rzn/fsp/src/r_sci_uart/: r_sci_uart.c
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/SVD/: RA.svd
    rzn/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    rzn_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: hal_entry.c
